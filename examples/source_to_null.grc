options:
  parameters:
    author: Astra918 contributors
    category: '[Astra918]'
    description: Minimal receiver and control block flowgraph
    generate_options: no_gui
    id: astra918_source_to_null
    output_language: python
    run: 'False'
    title: Astra918 source to null
  states: {}

blocks:
- name: astra918_source_0
  id: astra918_source
  parameters:
    serial: '""'
  states: {}
- name: astra918_control_0
  id: astra918_control
  parameters:
    receiver: astra918_source_0
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}

connections:
- [astra918_source_0, '0', blocks_null_sink_0, '0']
- [astra918_control_0, status, blocks_message_debug_0, print]

metadata:
  file_format: 1
