options:
  parameters:
    author: Astra918 contributors
    description: Live 120 ksps I/Q, firmware audio, optional CAT serial and receiver controls
    generate_options: qt_gui
    id: astra918_receiver_workbench
    output_language: python
    title: Astra918 receiver workbench
  states: {}

blocks:
- name: astra918_source_0
  id: astra918_source
  parameters:
    serial: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"120 kHz I/Q spectrum"'
    fftsize: '2048'
    fc: '14200000'
    bw: '120000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"120 kHz I/Q waterfall"'
    fftsize: '1024'
    fc: '14200000'
    bw: '120000'
  states: {}
- name: astra918_control_panel_0
  id: astra918_control_panel
  parameters:
    receiver: astra918_source_0
    spectrum_sink: '"qtgui_freq_sink_x_0"'
    waterfall_sink: '"qtgui_waterfall_sink_x_0"'
  states: {}
- name: astra918_audio_source_0
  id: astra918_audio_source
  parameters:
    device_name: '""'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '"Firmware USB audio (12 kHz)"'
    size: '2048'
    srate: '12000'
  states: {}
- name: astra918_cat_serial_0
  id: astra918_cat_serial
  parameters:
    port: '""'
    baud: '115200'
    poll_interval: '1.0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}

connections:
- [astra918_source_0, '0', qtgui_freq_sink_x_0, '0']
- [astra918_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [astra918_source_0, status, blocks_message_debug_0, print]
- [astra918_audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [astra918_cat_serial_0, text, blocks_message_debug_0, print]
- [astra918_cat_serial_0, bytes, blocks_message_debug_0, print_pdu]
- [astra918_cat_serial_0, status, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
